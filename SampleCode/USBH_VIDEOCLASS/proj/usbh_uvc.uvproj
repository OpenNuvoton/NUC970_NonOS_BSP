# Keil uVision project usbh_uvc.uvproj, settings and files
target usbh_uvc (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: usbh_uvc
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1
  c define: NO_TIMER
  c include: ..\..\..\Driver\Include;..\..\..\Library\USB_Host\Inc;..\..\..\Library\USB_Host\Inc\usb_uvc
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x2000000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\nuc970.sct
  link misc: --entry 0
  group src
    ../: main.c
  group src_usb_core
    ../../../Library/USB_Host/src_core/: urb.c usb.c usb_main.c hcd.c hub.c message.c config.c driver.c endpoint.c generic.c linux_bus_driver.c linux_fake.c support.c
    ../../../Library/USB_Host/src_core/host/: ehci-hcd.c ohci-hcd.c
  group Libraries
    ../../../Driver/Source/: standalone.c sys.c sys_timer.c sys_uart.c system_nuc970.c startup_NUC970.s sys_nuc970.s lcd.c
  group src_uvc
    ../../../Library/USB_Host/src_uvc/: uvc_ctrl.c uvc_driver.c uvc_queue.c uvc_status.c uvc_video.c linux_uvc_fake.c
