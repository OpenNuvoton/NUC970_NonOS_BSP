# Keil uVision project NAND_Yaffs2.uvproj, settings and files
target NAND_Yaffs2 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NAND_Yaffs2
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1
  c define: CONFIG_YAFFS_DIRECT, CONFIG_YAFFS_SHORT_NAMES_IN_RAM, CONFIG_YAFFS_YAFFS2, NO_Y_INLINE, CONFIG_YAFFS_PROVIDE_DEFS, CONFIG_YAFFSFS_PROVIDE_VALUES, __UBOOT__, CONFIG_MTD_PARTITIONS
  c misc: --diag_suppress=68,223,188,1293,61
  c include: ..\..\..\Driver\Include;..\..\..\ThirdParty\yaffs2\include;..\..\..\ThirdParty\yaffs2;..\..\..\ThirdParty\yaffs2\include\asm;..\..\..\ThirdParty\yaffs2\include\linux
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\nuc970.sct
  link misc: --entry 0
  group User
    ../: main.c yaffs_glue.c
  group Libraries
    ../../../Driver/Source/: standalone.c startup_NUC970.s sys.c sys_nuc970.s sys_timer.c sys_uart.c system_nuc970.c
  group YAFFS2
    ../../../ThirdParty/yaffs2/platform/: fmi_nand.c
    ../../../ThirdParty/yaffs2/: ctype.c linux_string.c mtdcore.c mtdpart.c nand.c nand_base.c nand_bbt.c nand_ids.c nand_util.c yaffs_allocator.c yaffs_attribs.c yaffs_bitmap.c yaffs_checkptrw.c yaffs_ecc.c yaffs_error.c yaffs_guts.c yaffs_hweight.c yaffs_malloc.c yaffs_mtdif.c yaffs_mtdif2.c yaffs_nameval.c yaffs_nand.c yaffs_packedtags1.c yaffs_packedtags2.c yaffs_qsort.c yaffs_summary.c yaffs_tagscompat.c yaffs_verify.c yaffs_yaffs1.c yaffs_yaffs2.c yaffsfs.c
