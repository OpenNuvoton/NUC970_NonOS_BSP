# Keil uVision project usbh_umass.uvproj, settings and files
target usbh_umas (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: usbh_umas
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: NO_TIMER
  c misc: --diag_suppress=4017
  c include: ..\..\..\Driver\Include;..\..\..\Library\USB_Host\Inc;..\..\..\Library\USB_Host\Inc\usb_umas;..\..\..\Library\USB_Host\lib;..\..\..\ThirdParty\FATFS\src
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x2000000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\nuc970.sct
  link misc: --entry 0
  group src
    ../: diskio.c main.c
  group src_usb_core
    ../../../Library/USB_Host/src_core/: urb.c usb.c usb_main.c hcd.c hub.c message.c config.c driver.c endpoint.c generic.c linux_bus_driver.c linux_fake.c support.c
    ../../../Library/USB_Host/src_core/host/: ehci-hcd.c ohci-hcd.c
  group src_usb_umas
    ../../../Library/USB_Host/src_umas/: UmasDebug.c UmasDriver.c UmasProtocol.c UmasScsiGlue.c UmasTransport.c
  group src_fatfs
    ../../../ThirdParty/FATFS/src/: ff.c
  group Libraries
    ../../../Driver/Source/: standalone.c sys.c sys_timer.c sys_uart.c system_nuc970.c startup_NUC970.s sys_nuc970.s
