# Keil uVision project SD_FATFS.uvproj, settings and files
target SD_FATFS (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: sd_fatfs
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1
  c include: ..\..\..\Driver\Include;..\..\..\ThirdParty\FATFS\src
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\nuc970.sct
  link misc: --entry 0
  group User
    ../: diskio.c main.c SDGlue.c
  group Libraries
    ../../../Driver/Source/: sdh.c standalone.c startup_NUC970.s sys.c sys_nuc970.s sys_timer.c sys_uart.c system_nuc970.c
  group FATFS
    ../../../ThirdParty/FATFS/src/: ff.c
