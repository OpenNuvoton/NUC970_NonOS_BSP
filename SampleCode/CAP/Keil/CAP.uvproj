# Keil uVision project CAP.uvproj, settings and files
target CAP (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: CAP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\Driver\Include
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\nuc970.sct
  link misc: --entry 0
  group src
    ../: i2c_gpio.c sensor_nt99141.c sensor_nt99050.c main.c sensor_hm1055.c
  group Libraries
    ../../../Driver/Source/: standalone.c sys.c sys_timer.c sys_uart.c system_nuc970.c startup_NUC970.s sys_nuc970.s cap.c lcd.c
